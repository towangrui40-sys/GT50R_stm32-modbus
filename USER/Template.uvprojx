# Keil uVision project Template.uvprojx, settings and files
target TestV1.0 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\port;..\modbus\include;..\modbus\ascii;..\modbus\rtu;..\modbus\tcp;..\HARDWARE;..\SYSTEM\gpio;..\SYSTEM\iic;..\SYSTEM\adc;..\SYSTEM\dac;..\modbus_m\functions;..\modbus_m\include;..\modbus_m\port;..\modbus_m\rtu
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
    ../modbus_m/port/: user_mb_app_m.c
  group CORE
    ./: system_stm32f10x.c
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_pwr.c stm32f10x_exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/gpio/: gpio.c
    ../SYSTEM/iic/: myiic.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/dac/: dac.c
    ../SYSTEM/usart/: usart.c
  group UCOSII_CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: os_cfg.h includes.h
  group HARDWARE
    ../HARDWARE/: Lis302dl.c Temp_ctrl.c
  group MODBUS
    ../modbus/ascii/: mbascii.c
    ../modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../modbus/rtu/: mbcrc.c mbrtu.c
    ../modbus/tcp/: mbtcp.c
    ../modbus/: mb.c
  group MODBUS_PORT
    ../port/: port.c portevent.c portserial.c porttimer.c
  group MODBUS_PORT_M
    ../modbus_m/port/rtt/: portevent_m.c portserial_m.c porttimer_m.c
  group MODBUS_M
    ../modbus_m/: mb_m.c
    ../modbus_m/functions/: mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c
    ../modbus_m/rtu/: mbrtu_m.c
software components: CMSIS:CORE 5.5.0
